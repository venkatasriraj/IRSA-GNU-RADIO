options:
  parameters:
    author: venka
    generate_options: qt_gui
    id: TX_c
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N_slots: '10'
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv


      # ─────────────────────────────────────────────────────────────────────────────
      #  IRSA_Packet_Generator
      #  Embedded Python Block for GNU Radio
      #
      #  Listens on 'frame_trigger' for a GNU Radio Message Strobe pulse.
      #  On each pulse it runs the IRSA algorithm for one frame:
      #    1.  Draw degree d  from Lambda_Dist (CDF form)
      #    2.  Select d unique random slots from [1 .. N_slots]
      #    3.  Build d identical packet copies (same payload, different slot headers)
      #    4.  Schedule each copy to fire at wall-clock time T_frame + (slot-1)*slot_dur
      #
      #  Packet byte layout (fixed-size header so the RX side can parse blindly):
      #
      #    Offset  Size  Field
      #    ──────  ────  ─────────────────────────────────────────────────────────
      #      0      4    access_code         [0xE1, 0x5A, 0xE8, 0x93]
      #      4      2    user_id             uint16 big-endian
      #      6      2    frame_seq           uint16 big-endian
      #      8      1    degree  (d)         uint8
      #      9      1    this_slot           uint8  (1-indexed slot of this copy)
      #     10      1    seed_lo             uint8  lower byte of per-frame RNG seed
      #     11      1    seed_hi             uint8  upper byte of per-frame RNG seed
      #     12      MAX_DEGREE  slot_list   d entries, zero-padded to MAX_DEGREE bytes
      #     12+MAX_DEGREE  ...  random_data fills rest of packet_size
      #     last 4       filler             [0xE1, 0x5A, 0xE8, 0xAA]
      #
      #  Notes
      #  ─────
      #  • All d copies share the SAME random_data.  This is mandatory for SIC:
      #    the receiver must be able to subtract bit-exact replicas.
      #  • A per-frame 16-bit seed is embedded so the receiver can independently
      #    regenerate and verify the random payload (optional but useful for SIC).
      #  • Slot timing uses threading.Timer against the wall clock captured the
      #    instant the frame_trigger message arrives.  Jitter is bounded by OS
      #    scheduling (~1–5 ms), which is acceptable for a software simulation.
      #    If you need tighter alignment, replace Timer with a busy-wait loop.
      #  • This block is purely message-driven (no streaming ports), so it must
      #    be gr.basic_block — NOT gr.sync_block.
      #
      #  GNU Radio Companion wiring
      #  ──────────────────────────
      #  Message Strobe  →  frame_trigger   (this block)
      #                      pdu_out        →  Async CRC32  →  Protocol Formatter
      #                                                      →  PDU to Tagged Stream
      #                                                      →  (rest of TX chain)
      # ─────────────────────────────────────────────────────────────────────────────

      # Sentinel: used to pad the slot_list field for unused entries
      _SLOT_PAD = 0x00

      class IRSA_Packet_Generator(gr.basic_block):

          # ── Default Lambda distribution (IRSA literature optimum) ─────────────
          #   Lambda = 0.5*x^2 + 0.28*x^3 + 0.22*x^8
          #   Stored as cumulative CDF: [(degree, cum_prob), ...]
          _DEFAULT_LAMBDA = [
              (2, 0.50),
              (3, 0.78),
              (8, 1.00),
          ]

          # ── Fixed access code (must match Correlate Access Code block at RX) ──
          _ACCESS_CODE = [0xE1, 0x5A, 0xE8, 0x93]
          # ── Filler appended at tail (helps framing / debugging) ───────────────
          _FILLER      = [0xE1, 0x5A, 0xE8, 0xAA]

          # Maximum degree supported by the fixed header layout
          MAX_DEGREE = 16

          def __init__(
              self,
              N_slots        = 100,
              slot_duration  = 0.04437,   # seconds — must match actual pkt air-time
              lambda_dist    = None,      # CDF list [(degree, cum_prob),...] or None
              user_id        = 1,
              packet_size    = 100,       # total bytes per copy (incl. header+filler)
              log_file       = "irsa_tx.csv",
              initial_delay  = 2.0,       # seconds — wait before accepting first frame
          ):
              gr.basic_block.__init__(
                  self,
                  name    = "irsa_packet_generator",
                  in_sig  = None,
                  out_sig = None,
              )

              # ── Message ports ─────────────────────────────────────────────────
              self.message_port_register_in(pmt.intern('frame_trigger'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('frame_trigger'), self._on_frame_trigger)

              # ── Parameters ────────────────────────────────────────────────────
              self.N_slots       = int(N_slots)
              self.slot_duration = float(slot_duration)
              self.user_id       = int(user_id) & 0xFFFF
              self.packet_size   = int(packet_size)
              self.log_file      = log_file
              self.initial_delay = float(initial_delay)

              # ── Lambda distribution (validate + store) ────────────────────────
              dist = lambda_dist if lambda_dist is not None else self._DEFAULT_LAMBDA
              self._validate_lambda(dist)
              self.lambda_dist = dist

              # ── Header size sanity check ──────────────────────────────────────
              # access_code(4) + user_id(2) + frame_seq(2) + degree(1) +
              # this_slot(1) + seed_lo(1) + seed_hi(1) + slot_list(MAX_DEGREE) + filler(4)
              self._fixed_header_bytes = (
                  len(self._ACCESS_CODE) + 2 + 2 + 1 + 1 + 1 + 1 +
                  self.MAX_DEGREE + len(self._FILLER)
              )
              if packet_size <= self._fixed_header_bytes:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > {self._fixed_header_bytes} "
                      f"to accommodate the fixed IRSA header."
                  )

              # ── Runtime state ──────────────────────────────────────────────────
              self._frame_seq   = 0
              self._timers      = []
              self._lock        = threading.Lock()
              self._ready       = False          # True after initial_delay has passed
              self._start_time  = time.time()

              # ── CSV log ────────────────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'frame_seq', 'user_id', 'degree',
                      'chosen_slots', 'this_slot', 'wall_clock_tx', 'rng_seed',
                  ])

              # ── Delayed-ready thread ───────────────────────────────────────────
              threading.Thread(
                  target  = self._warmup_wait,
                  daemon  = True,
                  name    = f"irsa_tx{user_id}_warmup",
              ).start()

              print(
                  f"[IRSA_TX{self.user_id}] Init: N_slots={N_slots}, "
                  f"slot_dur={slot_duration*1e3:.2f} ms, "
                  f"frame_dur={N_slots * slot_duration:.3f} s, "
                  f"lambda={dist}"
              )

          # ── Helpers ───────────────────────────────────────────────────────────

          @staticmethod
          def _validate_lambda(dist):
              """Ensure the CDF list is sorted, non-empty, and ends at 1.0."""
              if not dist:
                  raise ValueError("lambda_dist must be a non-empty list.")
              probs = [p for _, p in dist]
              if abs(probs[-1] - 1.0) > 1e-6:
                  raise ValueError(f"lambda_dist CDF must end at 1.0, got {probs[-1]}")
              if probs != sorted(probs):
                  raise ValueError("lambda_dist CDF probabilities must be non-decreasing.")

          def _warmup_wait(self):
              time.sleep(self.initial_delay)
              self._ready = True
              print(f"[IRSA_TX{self.user_id}] Ready — accepting frame triggers.")

          def _draw_degree(self) -> int:
              """Sample degree d from the Lambda CDF."""
              r = random.random()
              for degree, cum_prob in self.lambda_dist:
                  if r <= cum_prob:
                      return int(degree)
              return int(self.lambda_dist[-1][0])   # numerical safety fallback

          def _build_copy(
              self,
              frame_seq   : int,
              degree      : int,
              this_slot   : int,
              slot_list   : list,
              rng_seed    : int,
              random_data : list,
          ) -> list:
              """
              Assemble one packet copy for a specific slot.

              All copies within a frame share 'random_data' and 'rng_seed' so the
              receiver can replicate (and cancel) the payload during SIC.
              Only 'this_slot' differs between copies.
              """
              # ── Fixed header fields ────────────────────────────────────────────
              uid_bytes  = [(self.user_id >> 8) & 0xFF,  self.user_id & 0xFF]
              seq_bytes  = [(frame_seq   >> 8) & 0xFF,   frame_seq    & 0xFF]
              deg_byte   = [degree & 0xFF]
              slot_byte  = [this_slot & 0xFF]
              seed_bytes = [rng_seed & 0xFF, (rng_seed >> 8) & 0xFF]   # LE u16

              # Slot list: d entries, zero-padded to MAX_DEGREE
              slot_field  = [s & 0xFF for s in slot_list]
              slot_field += [_SLOT_PAD] * (self.MAX_DEGREE - len(slot_field))

              header = (
                  self._ACCESS_CODE +
                  uid_bytes  +
                  seq_bytes  +
                  deg_byte   +
                  slot_byte  +
                  seed_bytes +
                  slot_field
              )

              # header + random_data + filler = packet_size  (enforced at init time)
              return header + random_data + self._FILLER

          # ── Slot emission ──────────────────────────────────────────────────────

          def _emit_slot(
              self,
              frame_seq   : int,
              degree      : int,
              this_slot   : int,
              slot_list   : list,
              rng_seed    : int,
              random_data : list,
          ):
              """
              Timer callback: build the packet for this slot and publish it as a PDU.
              Runs in a daemon thread — keep it short and thread-safe.
              """
              data = self._build_copy(
                  frame_seq, degree, this_slot, slot_list, rng_seed, random_data
              )

              # ── PMT metadata ──────────────────────────────────────────────────
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('user_id'),   pmt.from_long(self.user_id))
              meta = pmt.dict_add(meta, pmt.intern('frame_seq'), pmt.from_long(frame_seq))
              meta = pmt.dict_add(meta, pmt.intern('degree'),    pmt.from_long(degree))
              meta = pmt.dict_add(meta, pmt.intern('this_slot'), pmt.from_long(this_slot))
              # 'packet_num' consumed by Protocol Formatter / Packet Header Generator
              meta = pmt.dict_add(meta, pmt.intern('packet_num'),pmt.from_long(frame_seq))

              pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

              # ── CSV log ────────────────────────────────────────────────────────
              ts = (time.strftime('%Y-%m-%d %H:%M:%S') +
                    f".{int((time.time() % 1) * 1000):03d}")
              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      frame_seq, self.user_id, degree,
                      slot_list, this_slot, ts, f"0x{rng_seed:04X}",
                  ])

              print(
                  f"[IRSA_TX{self.user_id}] "
                  f"Frame={frame_seq:04d}  Slot={this_slot:03d}/{self.N_slots}  "
                  f"d={degree}  copies@{slot_list}  seed=0x{rng_seed:04X}"
              )

          # ── Frame trigger handler ──────────────────────────────────────────────

          def _on_frame_trigger(self, msg):
              """
              GNU Radio calls this in the scheduler thread when a strobe fires.
              Must return quickly — all slot transmissions are dispatched to
              threading.Timer callbacks so we don't block the scheduler.
              """
              if not self._ready:
                  print(f"[IRSA_TX{self.user_id}] Frame trigger ignored — still in warmup.")
                  return

              frame_seq = self._frame_seq
              self._frame_seq = (self._frame_seq + 1) & 0xFFFF

              # ── IRSA Algorithm ─────────────────────────────────────────────────
              # Step 1: Draw degree
              degree = self._draw_degree()

              # Step 2: Select d unique slots (1-indexed)
              chosen_slots = sorted(random.sample(range(1, self.N_slots + 1), degree))

              # Step 3: Generate shared payload ONCE — identical across all d copies
              rng_seed    = random.randint(0, 0xFFFF)
              payload_len = (
                  self.packet_size
                  - self._fixed_header_bytes
              )
              rng = random.Random(rng_seed)   # seeded sub-RNG for reproducibility
              random_data = [rng.randint(0, 255) for _ in range(payload_len)]

              print(
                  f"[IRSA_TX{self.user_id}] "
                  f"Frame={frame_seq:04d}  d={degree}  slots={chosen_slots}"
              )

              # ── Step 4: Schedule one PDU per chosen slot ───────────────────────
              t_frame = time.time()   # wall-clock anchor for this frame

              with self._lock:
                  # Clean up any completed timers from previous frames
                  self._timers = [t for t in self._timers if t.is_alive()]

                  for slot in chosen_slots:
                      # Slot k starts at (k-1) * slot_duration after frame anchor
                      delay = (slot - 1) * self.slot_duration

                      t = threading.Timer(
                          interval = delay,
                          function = self._emit_slot,
                          args     = (frame_seq, degree, slot,
                                      chosen_slots, rng_seed, random_data),
                      )
                      t.daemon = True
                      t.start()
                      self._timers.append(t)

          # ── GNU Radio lifecycle ────────────────────────────────────────────────

          def stop(self):
              """Cancel all pending slot timers on flowgraph stop."""
              with self._lock:
                  for t in self._timers:
                      t.cancel()
                  self._timers.clear()
              print(f"[IRSA_TX{self.user_id}] Stopped. Frame count: {self._frame_seq}")
              return True
    initial_delay: ''
    lambda_dist: ''
    log_file: ''
    packet_size: ''
    slot_duration: ''
    user_id: ''
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, frame_trigger]
- [epy_block_0, pdu_out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
