options:
  parameters:
    author: Barry Duggan
    description: packet receive
    generate_options: qt_gui
    id: pkt_rcv_strip
    output_language: python
    title: pkt_rcv_strip
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: Infile
  id: parameter
  parameters:
    label: filename
    type: str
    value: log.txt
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ./output_meta.tmp
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./output_initial.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: ./output_data.tmp
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '1'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, output_file="decoded_packets.bin"):
              gr.sync_block.__init__(
                  self,
                  name='EPB: Decode Packet',
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
              self.output_file = output_file
              self.packet_count = 0
              
          def handle_msg(self, msg):
              _debug = 1  # set to 1 for diagnostics, 0 to disable
              
              try:
                  # Extract the data portion from PDU
                  buff = pmt.to_python(pmt.cdr(msg))
              except Exception as e:
                  gr.log.error("Error with message conversion: %s" % str(e))
                  return
              
              if buff is None or len(buff) == 0:
                  gr.log.warn("Received empty packet")
                  return
                  
              b_len = len(buff)
              self.packet_count += 1
              
              if _debug:
                  print(f"\n=== Packet #{self.packet_count} ===")
                  print(f"Length: {b_len} bytes")
                  print(f"Data (hex): {' '.join(f'{b:02x}' for b in buff[:min(32, b_len)])}")
                  if b_len > 32:
                      print(f"... ({b_len - 32} more bytes)")
              
              # Convert to numpy array for easier manipulation
              data = np.frombuffer(buff, dtype=np.uint8)
              
              # Store to file
              try:
                  with open(self.output_file, 'ab') as f:  # append binary mode
                      # Write packet with header: [packet_len (2 bytes)][data]
                      header = np.array([b_len & 0xFF, (b_len >> 8) & 0xFF], dtype=np.uint8)
                      header.tofile(f)
                      data.tofile(f)
                  
                  if _debug:
                      print(f"Saved to: {self.output_file}")
                      
              except Exception as e:
                  gr.log.error(f"Error writing to file: {str(e)}")
              
              # Forward the packet downstream
              pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data), list(data)))
              self.message_port_pub(pmt.intern('msg_out'), pdu)
    comment: |-
      Strip preamble and postamble
      Convert Base64 to original file content
    output_file: output_filename
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, filename="pdu_log.txt"):
              gr.sync_block.__init__(
                  self,
                  name="pdu_logger",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)
              
              self.log_file = open(filename, 'w')
              self.packet_count = 0
              
          def handle_pdu(self, pdu):
              # Log PDU metadata
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)
              
              timestamp = time.time()
              self.packet_count += 1
              
              # Write to log file
              log_entry = f"Packet {self.packet_count} | Time: {timestamp} | "
              log_entry += f"Length: {pmt.length(data)} bytes\n"
              
              if pmt.is_dict(meta):
                  log_entry += f"Metadata: {pmt.to_python(meta)}\n"
              
              self.log_file.write(log_entry)
              self.log_file.flush()
              
              # Pass PDU through
              self.message_port_pub(pmt.intern('pdu_out'), pdu)
          
          def __del__(self):
              self.log_file.close()
    filename: Infile
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq
    timestamp_filename: timestamp
  states: {}
- name: iq
  id: parameter
  parameters:
    label: filename
    type: str
    value: iq_samplesRx.dat
  states: {}
- name: output_filename
  id: parameter
  parameters:
    label: file
    type: str
    value: output.bin
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(usrp_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: timestamp
  id: parameter
  parameters:
    label: filename
    type: str
    value: timestampsRx.txt
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_meta_sink_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_1, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, msg_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1, pdu_out, epy_block_0, msg_in]
- [epy_block_2, '0', digital_constellation_decoder_cb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_1, pdu_in]
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_2, '0', digital_map_bb_0, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
