options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: file.txt
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: tx1
    type: complex
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    name: tx2
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52, mean_interval=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source with Random Packet Generator', # to Tagged Stream \n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len # in Bytes\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n        self.nitems_written = 0\n\n        # adding to the existing code to have random packet generator with mean interval between packets\n        self.mean_interval = mean_interval # mean interval between packets in seconds\n\n        if os.path.exists(self.FileName):\n            self.f_in = open(self.FileName, 'rb')\n            self._eof = False\n            if self._debug:\n                print(\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [\n            37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.c_len = len(self.char_list)\n\n        self.filler = [\n            37,85,85,85,35,69,79,70,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.f_len = len(self.filler)\n\n    def work(self, input_items, output_items):\n\n        while True:\n            if self.state == 0:\n                return 0\n            else:\n                wait_time = np.random.exponential(self.mean_interval)\n                time.sleep(wait_time)\n                \n                # if self.state == 0:\n                #     return 0\n\n                if self.state == 1:\n\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('File is empty')\n                        self._eof = False\n                        self.f_in.close()\n                        self.state = 0\n                        self.pre_count = 0\n                        return 0\n\n                    if self._debug:\n                        print(\"state = 1\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.c_len)\n\n                    if len(output_items[0]) < self.c_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.c_len\n                    self.nitems_written += self.c_len\n\n                    i = 0\n                    while i < self.c_len:\n                        output_items[0][i] = self.char_list[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 64:\n                        self.pre_count = 0\n                        self.state = 2\n\n                    return self.c_len\n\n                elif self.state == 2:\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('End of file')\n                        self._eof = True\n                        self.f_in.close()\n                        self.state = 3\n                        self.pre_count = 0\n                        return 0\n\n                    encoded = base64.b64encode(buff)\n                    e_len = len(encoded)\n\n                    if self._debug:\n                        print('b64 length =', e_len)\n\n                    key0 = pmt.intern(\"packet_len\")\n                    val0 = pmt.from_long(e_len)\n\n                    if len(output_items[0]) < e_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key0,\n                        val0\n                    )\n\n                    self.indx += e_len\n                    self.nitems_written += e_len\n\n                    i = 0\n                    while i < e_len:\n                        output_items[0][i] = encoded[i]\n                        i += 1\n\n                    return e_len\n\n                elif self.state == 3:\n                    fn_len = len(self.FileName)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(fn_len + 8)\n\n                    if len(output_items[0]) < fn_len + 8:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += fn_len + 8\n                    self.nitems_written += fn_len + 8\n\n                    i = 0\n                    while i < 8:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    j = 0\n                    while i < (fn_len + 8):\n                        output_items[0][i] = ord(self.FileName[j])\n                        i += 1\n                        j += 1\n\n                    self.state = 4\n                    return fn_len + 8\n\n                elif self.state == 4:\n                    if self._debug:\n                        print(\"state = 4\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.f_len)\n\n                    if len(output_items[0]) < self.f_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.f_len\n                    self.nitems_written += self.f_len\n\n                    i = 0\n                    while i < self.f_len:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 16:\n                        self.pre_count = 0\n                        self.state = 0\n\n                    return self.f_len\n\n                return 0\n        \n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    mean_interval: '0.1'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52, mean_interval=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source with Random Packet Generator', # to Tagged Stream \n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len # in Bytes\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n        self.nitems_written = 0\n\n        # adding to the existing code to have random packet generator with mean interval between packets\n        self.mean_interval = mean_interval # mean interval between packets in seconds\n\n        if os.path.exists(self.FileName):\n            self.f_in = open(self.FileName, 'rb')\n            self._eof = False\n            if self._debug:\n                print(\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [\n            37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.c_len = len(self.char_list)\n\n        self.filler = [\n            37,85,85,85,35,69,79,70,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.f_len = len(self.filler)\n\n    def work(self, input_items, output_items):\n\n        while True:\n            if self.state == 0:\n                return 0\n            else:\n                wait_time = np.random.exponential(self.mean_interval)\n                time.sleep(wait_time)\n                \n                # if self.state == 0:\n                #     return 0\n\n                if self.state == 1:\n\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('File is empty')\n                        self._eof = False\n                        self.f_in.close()\n                        self.state = 0\n                        self.pre_count = 0\n                        return 0\n\n                    if self._debug:\n                        print(\"state = 1\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.c_len)\n\n                    if len(output_items[0]) < self.c_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.c_len\n                    self.nitems_written += self.c_len\n\n                    i = 0\n                    while i < self.c_len:\n                        output_items[0][i] = self.char_list[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 64:\n                        self.pre_count = 0\n                        self.state = 2\n\n                    return self.c_len\n\n                elif self.state == 2:\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('End of file')\n                        self._eof = True\n                        self.f_in.close()\n                        self.state = 3\n                        self.pre_count = 0\n                        return 0\n\n                    encoded = base64.b64encode(buff)\n                    e_len = len(encoded)\n\n                    if self._debug:\n                        print('b64 length =', e_len)\n\n                    key0 = pmt.intern(\"packet_len\")\n                    val0 = pmt.from_long(e_len)\n\n                    if len(output_items[0]) < e_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key0,\n                        val0\n                    )\n\n                    self.indx += e_len\n                    self.nitems_written += e_len\n\n                    i = 0\n                    while i < e_len:\n                        output_items[0][i] = encoded[i]\n                        i += 1\n\n                    return e_len\n\n                elif self.state == 3:\n                    fn_len = len(self.FileName)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(fn_len + 8)\n\n                    if len(output_items[0]) < fn_len + 8:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += fn_len + 8\n                    self.nitems_written += fn_len + 8\n\n                    i = 0\n                    while i < 8:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    j = 0\n                    while i < (fn_len + 8):\n                        output_items[0][i] = ord(self.FileName[j])\n                        i += 1\n                        j += 1\n\n                    self.state = 4\n                    return fn_len + 8\n\n                elif self.state == 4:\n                    if self._debug:\n                        print(\"state = 4\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.f_len)\n\n                    if len(output_items[0]) < self.f_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.f_len\n                    self.nitems_written += self.f_len\n\n                    i = 0\n                    while i < self.f_len:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 16:\n                        self.pre_count = 0\n                        self.state = 0\n\n                    return self.f_len\n\n                return 0\n        \n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    mean_interval: '0.1'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_1
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_2
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_2
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq2_2
  states: {}
- name: epy_block_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq_add
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq2_1
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv"):

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = 3

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              """
              Assemble the byte payload:
                  [seq_hi, seq_lo, uid_hi, uid_lo, *random_bytes]
              """
              header = [
                  (seq          >> 8) & 0xFF,   # seq high byte
                   seq                & 0xFF,   # seq low byte
                  (self.user_id >> 8) & 0xFF,   # user_id high byte
                   self.user_id       & 0xFF,   # user_id low byte
              ]
              random_bytes = [random.randint(0, 255)
                              for _ in range(self.packet_size - len(header))]
              return header + random_bytes

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              time.sleep(random.uniform(0, self.mean_interval))
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    log_file: log_file1
    mean_interval: '3'
    packet_size: '52'
    user_id: '1'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv"):

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = 1
              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              """
              Assemble the byte payload:
                  [seq_hi, seq_lo, uid_hi, uid_lo, *random_bytes]
              """
              header = [
                  (seq          >> 8) & 0xFF,   # seq high byte
                   seq                & 0xFF,   # seq low byte
                  (self.user_id >> 8) & 0xFF,   # user_id high byte
                   self.user_id       & 0xFF,   # user_id low byte
              ]
              random_bytes = [random.randint(0, 255)
                              for _ in range(self.packet_size - len(header))]
              return header + random_bytes

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              time.sleep(random.uniform(0, self.mean_interval))
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    log_file: log_file2
    mean_interval: '10'
    packet_size: '52'
    user_id: '2'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Energy-Based Tag Deduplicator for ALOHA Add-Block Channel\n    ----------------------------------------------------------\n    Takes THREE inputs:\n      in0 = Add block output  (combined signal  → passed to output)\n      in1 = User 1 stream     (energy monitor only, not passed out)\n      in2 = User 2 stream     (energy monitor only, not passed out)\n\n    Detects which users are ACTUALLY transmitting based on signal\n    energy, then emits clean tags accordingly.\n    \"\"\"\n\n    # Threshold below which a stream is considered silent\n    ENERGY_THRESHOLD = 1e-6\n\n    def __init__(self, packet_samples=34079):\n        gr.sync_block.__init__(\n            self,\n            name=\"aloha_tag_dedup\",\n            in_sig=[np.complex64,   # in0: Add output  → goes to out\n                    np.complex64,   # in1: User 1 raw stream\n                    np.complex64],  # in2: User 2 raw stream\n            out_sig=[np.complex64]\n        )\n        self.packet_samples = packet_samples\n        self.set_tag_propagation_policy(gr.TPP_DONT)  # block all auto tags\n\n    def _stream_has_energy(self, samples):\n        \"\"\"Returns True if stream has actual packet data (non-silence).\"\"\"\n        power = np.mean(np.abs(samples) ** 2)\n        return power > self.ENERGY_THRESHOLD\n\n    def work(self, input_items, output_items):\n        combined = input_items[0]   # Add block output\n        user1    = input_items[1]   # User 1 raw\n        user2    = input_items[2]   # User 2 raw\n\n        output_items[0][:] = combined  # pass combined signal through\n\n        # ── Get packet_len tags from the combined stream ────────────\n        tags = self.get_tags_in_window(\n            0, 0, len(combined), pmt.intern(\"packet_len\")\n        )\n\n        for tag in tags:\n            offset = tag.offset\n\n            # Window of samples around this tag in each user stream\n            # (relative to this work() call's starting offset)\n            abs_start = self.nitems_written(0)\n            rel_offset = offset - abs_start\n\n            # Slice packet window from each user's stream\n            start = rel_offset\n            end   = min(rel_offset + self.packet_samples, len(user1))\n\n            u1_active = self._stream_has_energy(user1[start:end])\n            u2_active = self._stream_has_energy(user2[start:end])\n\n            # ── Decision ───────────────────────────────────────────\n            if u1_active and u2_active:\n                # COLLISION — emit single packet_len tag\n                # RX will attempt decode → CRC will fail → correct\n                self.add_item_tag(0, offset, tag.key, tag.value)\n                print(f\"[TagDedup] offset={offset} → COLLISION \"\n                      f\"(both users active) — 1 tag emitted, CRC will fail\")\n\n            elif u1_active:\n                # Only User 1 — emit clean tags\n                self.add_item_tag(0, offset, tag.key, tag.value)\n                self._copy_user_tags(0, offset)\n                print(f\"[TagDedup] offset={offset} → User 1 only — clean\")\n\n            elif u2_active:\n                # Only User 2 — emit clean tags\n                self.add_item_tag(0, offset, tag.key, tag.value)\n                self._copy_user_tags(1, offset)\n                print(f\"[TagDedup] offset={offset} → User 2 only — clean\")\n\n            else:\n                # Neither active — silence, no tag needed\n                print(f\"[TagDedup] offset={offset} → silence, tag dropped\")\n\n        return len(combined)\n\n    def _copy_user_tags(self, port, offset):\n        \"\"\"Copy user_id and seq_num tags from a specific input port.\"\"\"\n        for key in [\"user_id\", \"seq_num\", \"tx_time\"]:\n            tags = self.get_tags_in_window(\n                port, 0,\n                len(self.input_items[port]),   # full window\n                pmt.intern(key)\n            )\n            for t in tags:\n                if t.offset == offset:\n                    self.add_item_tag(0, offset, t.key, t.value)\n\"\"\"\n### Updated Flowgraph\n\nf_samp1 ──► iq_logger ──┬──────────────────────────────► in1 (energy monitor)\n                         │                                      │\n                         ├──► Add ──► in0 [aloha_tag_dedup] ──► out ──► ZMQ PUB\n                         │                    ▲\nf_samp2 ──► iq_logger ──┴──────────────────► in2 (energy monitor)\n\n\n### What Changes Per Scenario\n\nSlot where only User 1 transmits:\n  u1_active = True  (high energy)\n  u2_active = False (near-zero energy)\n  → emit packet_len + user_id=1 + seq_num=N\n  → RX decodes → CRC passes ✓\n\nSlot where only User 2 transmits:\n  u1_active = False\n  u2_active = True\n  → emit packet_len + user_id=2 + seq_num=M\n  → RX decodes → CRC passes ✓\n\nSlot where both transmit (collision):\n  u1_active = True\n  u2_active = True\n  → emit single packet_len only (no user identity)\n  → RX attempts decode → CRC FAILS → packet lost ✓\n\nSilence slot:\n  u1_active = False\n  u2_active = False\n  → no tag emitted ✓\n\"\"\"\n\n"
    packet_samples: '34079'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):

          def __init__(self, user_id=0, samp_rate=768000, packet_samples=100000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.user_id         = user_id
              self.samp_rate       = samp_rate
              self.packet_samples  = packet_samples
              self.seq_num         = 0
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              # ── Use pmt.intern() directly, NOT self.pmt_intern() ──
              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")   # ← pmt.intern not self.pmt_intern
              )

              for tag in tags:
                  offset  = tag.offset

                  # Measure actual packet samples between tags
                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      #print(f"[User {self.user_id}] "
                      #      f"Measured packet_samples = {measured}")
                  self.last_tag_offset = offset

                  self.seq_num += 1

                  # Add user_id tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("user_id"),         # ← pmt.intern
                      pmt.from_long(self.user_id)    # ← pmt.from_long
                  )

                  # Add sequence number tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("seq_num"),
                      pmt.from_long(self.seq_num)
                  )

                  # Add timestamp tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("tx_time"),
                      pmt.from_double(time.time())   # ← pmt.from_double
                  )

                  print(f"[User {self.user_id}] Tagged PKT "
                        f"seq={self.seq_num} offset={offset}")

              return len(inp)
    packet_samples: '34079'
    samp_rate: samp_rate
    user_id: user_id1
  states: {state: disabled}
- name: epy_block_3_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):

          def __init__(self, user_id=0, samp_rate=768000, packet_samples=100000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.user_id         = user_id
              self.samp_rate       = samp_rate
              self.packet_samples  = packet_samples
              self.seq_num         = 0
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              # ── Use pmt.intern() directly, NOT self.pmt_intern() ──
              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")   # ← pmt.intern not self.pmt_intern
              )

              for tag in tags:
                  offset  = tag.offset

                  # Measure actual packet samples between tags
                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      #print(f"[User {self.user_id}] "
                      #      f"Measured packet_samples = {measured}")
                  self.last_tag_offset = offset

                  self.seq_num += 1

                  # Add user_id tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("user_id"),         # ← pmt.intern
                      pmt.from_long(self.user_id)    # ← pmt.from_long
                  )

                  # Add sequence number tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("seq_num"),
                      pmt.from_long(self.seq_num)
                  )

                  # Add timestamp tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("tx_time"),
                      pmt.from_double(time.time())   # ← pmt.from_double
                  )

                  print(f"[User {self.user_id}] Tagged PKT "
                        f"seq={self.seq_num} offset={offset}")

              return len(inp)
    packet_samples: '34079'
    samp_rate: samp_rate
    user_id: user_id2
  states: {state: disabled}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX1.csv
  states: {}
- name: iq1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd1.csv
  states: {}
- name: iq2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX2.csv
  states: {}
- name: iq2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd2.csv
  states: {}
- name: iq_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_Aadd.csv
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data 1
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 2,0,1,3
    label1: ''
    name: Transmit data 2
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: timestamp1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps1_1.txt
  states: {}
- name: timestamp1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx1_2.txt
  states: {}
- name: timestamp2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps2_1.txt
  states: {}
- name: timestamp2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx2_2.txt
  states: {}
- name: timestamp_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamp_add.txt
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: f_samp2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: f_samp2
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:49203
    bind: 'False'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', epy_block_3, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', epy_block_1_0_0_1, '0']
- [blocks_throttle2_0_0, '0', epy_block_1_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_file_meta_sink_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_file_meta_sink_0_0, '0']
- [digital_constellation_modulator_0_0, '0', epy_block_1_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_crc32_bb_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_0_0, '0', digital_crc32_bb_0_0, '0']
- [epy_block_1, '0', fft_filter_xxx_0_0_0, '0']
- [epy_block_1_0, '0', zeromq_pub_sink_0_0, '0']
- [epy_block_1_0, '0', zeromq_push_sink_0, '0']
- [epy_block_1_0_0, '0', blocks_add_xx_0, '0']
- [epy_block_1_0_0_0, '0', blocks_add_xx_0, '1']
- [epy_block_1_0_0_1, '0', zeromq_pub_sink_0, '0']
- [epy_block_1_1, '0', fft_filter_xxx_0_0_0_0, '0']
- [epy_block_2, pdu_out, blocks_message_debug_0, print]
- [epy_block_2, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_2_0, pdu_out, blocks_message_debug_0_0, print]
- [epy_block_2_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_3_0, '0', virtual_sink_0, '0']
- [epy_block_3_0_0, '0', virtual_sink_0_1, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [fft_filter_xxx_0_0_0_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_tag_debug_0, '0']
- [mmse_resampler_xx_0, '0', epy_block_3_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_tag_debug_0_0, '0']
- [mmse_resampler_xx_0_0, '0', epy_block_3_0_0, '0']
- [mmse_resampler_xx_0_0, '0', virtual_sink_0_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', blocks_throttle2_0_0, '0']
- [virtual_source_1_1, '0', epy_block_1_0_0, '0']
- [virtual_source_1_1_0, '0', epy_block_1_0_0_0, '0']
- [virtual_source_1_1_0, '0', epy_block_3, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
