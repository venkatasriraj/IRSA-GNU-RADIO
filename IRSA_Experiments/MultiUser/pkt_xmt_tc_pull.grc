options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: user_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: file.txt
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52, mean_interval=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source with Random Packet Generator', # to Tagged Stream \n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len # in Bytes\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n        self.nitems_written = 0\n\n        # adding to the existing code to have random packet generator with mean interval between packets\n        self.mean_interval = mean_interval # mean interval between packets in seconds\n\n        if os.path.exists(self.FileName):\n            self.f_in = open(self.FileName, 'rb')\n            self._eof = False\n            if self._debug:\n                print(\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [\n            37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.c_len = len(self.char_list)\n\n        self.filler = [\n            37,85,85,85,35,69,79,70,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.f_len = len(self.filler)\n\n    def work(self, input_items, output_items):\n\n        while True:\n            if self.state == 0:\n                return 0\n            else:\n                wait_time = np.random.exponential(self.mean_interval)\n                time.sleep(wait_time)\n                \n                # if self.state == 0:\n                #     return 0\n\n                if self.state == 1:\n\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('File is empty')\n                        self._eof = False\n                        self.f_in.close()\n                        self.state = 0\n                        self.pre_count = 0\n                        return 0\n\n                    if self._debug:\n                        print(\"state = 1\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.c_len)\n\n                    if len(output_items[0]) < self.c_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.c_len\n                    self.nitems_written += self.c_len\n\n                    i = 0\n                    while i < self.c_len:\n                        output_items[0][i] = self.char_list[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 64:\n                        self.pre_count = 0\n                        self.state = 2\n\n                    return self.c_len\n\n                elif self.state == 2:\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('End of file')\n                        self._eof = True\n                        self.f_in.close()\n                        self.state = 3\n                        self.pre_count = 0\n                        return 0\n\n                    encoded = base64.b64encode(buff)\n                    e_len = len(encoded)\n\n                    if self._debug:\n                        print('b64 length =', e_len)\n\n                    key0 = pmt.intern(\"packet_len\")\n                    val0 = pmt.from_long(e_len)\n\n                    if len(output_items[0]) < e_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key0,\n                        val0\n                    )\n\n                    self.indx += e_len\n                    self.nitems_written += e_len\n\n                    i = 0\n                    while i < e_len:\n                        output_items[0][i] = encoded[i]\n                        i += 1\n\n                    return e_len\n\n                elif self.state == 3:\n                    fn_len = len(self.FileName)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(fn_len + 8)\n\n                    if len(output_items[0]) < fn_len + 8:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += fn_len + 8\n                    self.nitems_written += fn_len + 8\n\n                    i = 0\n                    while i < 8:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    j = 0\n                    while i < (fn_len + 8):\n                        output_items[0][i] = ord(self.FileName[j])\n                        i += 1\n                        j += 1\n\n                    self.state = 4\n                    return fn_len + 8\n\n                elif self.state == 4:\n                    if self._debug:\n                        print(\"state = 4\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.f_len)\n\n                    if len(output_items[0]) < self.f_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.f_len\n                    self.nitems_written += self.f_len\n\n                    i = 0\n                    while i < self.f_len:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 16:\n                        self.pre_count = 0\n                        self.state = 0\n\n                    return self.f_len\n\n                return 0\n        \n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    mean_interval: '0.1'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52, mean_interval=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source with Random Packet Generator', # to Tagged Stream \n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len # in Bytes\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n        self.nitems_written = 0\n\n        # adding to the existing code to have random packet generator with mean interval between packets\n        self.mean_interval = mean_interval # mean interval between packets in seconds\n\n        if os.path.exists(self.FileName):\n            self.f_in = open(self.FileName, 'rb')\n            self._eof = False\n            if self._debug:\n                print(\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [\n            37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.c_len = len(self.char_list)\n\n        self.filler = [\n            37,85,85,85,35,69,79,70,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.f_len = len(self.filler)\n\n    def work(self, input_items, output_items):\n\n        while True:\n            if self.state == 0:\n                return 0\n            else:\n                wait_time = np.random.exponential(self.mean_interval)\n                time.sleep(wait_time)\n                \n                # if self.state == 0:\n                #     return 0\n\n                if self.state == 1:\n\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('File is empty')\n                        self._eof = False\n                        self.f_in.close()\n                        self.state = 0\n                        self.pre_count = 0\n                        return 0\n\n                    if self._debug:\n                        print(\"state = 1\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.c_len)\n\n                    if len(output_items[0]) < self.c_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.c_len\n                    self.nitems_written += self.c_len\n\n                    i = 0\n                    while i < self.c_len:\n                        output_items[0][i] = self.char_list[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 64:\n                        self.pre_count = 0\n                        self.state = 2\n\n                    return self.c_len\n\n                elif self.state == 2:\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('End of file')\n                        self._eof = True\n                        self.f_in.close()\n                        self.state = 3\n                        self.pre_count = 0\n                        return 0\n\n                    encoded = base64.b64encode(buff)\n                    e_len = len(encoded)\n\n                    if self._debug:\n                        print('b64 length =', e_len)\n\n                    key0 = pmt.intern(\"packet_len\")\n                    val0 = pmt.from_long(e_len)\n\n                    if len(output_items[0]) < e_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key0,\n                        val0\n                    )\n\n                    self.indx += e_len\n                    self.nitems_written += e_len\n\n                    i = 0\n                    while i < e_len:\n                        output_items[0][i] = encoded[i]\n                        i += 1\n\n                    return e_len\n\n                elif self.state == 3:\n                    fn_len = len(self.FileName)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(fn_len + 8)\n\n                    if len(output_items[0]) < fn_len + 8:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += fn_len + 8\n                    self.nitems_written += fn_len + 8\n\n                    i = 0\n                    while i < 8:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    j = 0\n                    while i < (fn_len + 8):\n                        output_items[0][i] = ord(self.FileName[j])\n                        i += 1\n                        j += 1\n\n                    self.state = 4\n                    return fn_len + 8\n\n                elif self.state == 4:\n                    if self._debug:\n                        print(\"state = 4\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.f_len)\n\n                    if len(output_items[0]) < self.f_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.f_len\n                    self.nitems_written += self.f_len\n\n                    i = 0\n                    while i < self.f_len:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 16:\n                        self.pre_count = 0\n                        self.state = 0\n\n                    return self.f_len\n\n                return 0\n        \n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    mean_interval: '0.1'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq1_1
    timestamp_filename: timestamp1_1
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq1_2
    timestamp_filename: timestamp1_2
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq1_2
    timestamp_filename: timestamp1_2
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq2_2
    timestamp_filename: timestamp2_2
  states: {}
- name: epy_block_1_0_0_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq_add
    timestamp_filename: timestamp_add
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq2_1
    timestamp_filename: timestamp2_1
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading

      class Random_Packet_Generator(gr.basic_block):
          def __init__(self, mean_interval=0.1, packet_size=100):
              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.mean_interval = mean_interval
              self.packet_size = packet_size
              self.total_packets = 100
              self.packet_count = 0
              self.thread = threading.Thread(target=self.generate_packets)
              self.thread.daemon = True
              self.thread.start()
          
          def generate_packets(self):
              while self.packet_count < self.total_packets:
                  # Random wait time (uniform distribution)
                  #wait_time = random.uniform(0, 2 * self.mean_interval)
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)
                  
                  # Generate random packet data
                  data = [random.randint(0, 255) for _ in range(self.packet_size)]
                  #print(data)
                  pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data), data))
                  self.packet_count += 1
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  print(f"Packet transmitted after {wait_time:.3f}s wait")
    mean_interval: '5'
    packet_size: '52'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading

      class Random_Packet_Generator(gr.basic_block):
          def __init__(self, mean_interval=0.1, packet_size=100):
              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.mean_interval = mean_interval
              self.packet_size = packet_size
              self.total_packets = 100
              self.packet_count = 0
              self.thread = threading.Thread(target=self.generate_packets)
              self.thread.daemon = True
              self.thread.start()
          
          def generate_packets(self):
              while self.packet_count < self.total_packets:
                  # Random wait time (uniform distribution)
                  #wait_time = random.uniform(0, 2 * self.mean_interval)
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)
                  
                  # Generate random packet data
                  data = [random.randint(0, 255) for _ in range(self.packet_size)]
                  #print(data)
                  pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data), data))
                  self.packet_count += 1
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  print(f"Packet transmitted after {wait_time:.3f}s wait")
    mean_interval: '5'
    packet_size: '52'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):

          def __init__(self, user_id=0, samp_rate=768000, packet_samples=100000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.user_id         = user_id
              self.samp_rate       = samp_rate
              self.packet_samples  = packet_samples
              self.seq_num         = 0
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              # ── Use pmt.intern() directly, NOT self.pmt_intern() ──
              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")   # ← pmt.intern not self.pmt_intern
              )

              for tag in tags:
                  offset  = tag.offset

                  # Measure actual packet samples between tags
                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      #print(f"[User {self.user_id}] "
                      #      f"Measured packet_samples = {measured}")
                  self.last_tag_offset = offset

                  self.seq_num += 1

                  # Add user_id tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("user_id"),         # ← pmt.intern
                      pmt.from_long(self.user_id)    # ← pmt.from_long
                  )

                  # Add sequence number tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("seq_num"),
                      pmt.from_long(self.seq_num)
                  )

                  # Add timestamp tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("tx_time"),
                      pmt.from_double(time.time())   # ← pmt.from_double
                  )

                  print(f"[User {self.user_id}] Tagged PKT "
                        f"seq={self.seq_num} offset={offset}")

              return len(inp)
    packet_samples: '34079'
    samp_rate: samp_rate
    user_id: user_id
  states: {}
- name: epy_block_3_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):

          def __init__(self, user_id=0, samp_rate=768000, packet_samples=100000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.user_id         = user_id
              self.samp_rate       = samp_rate
              self.packet_samples  = packet_samples
              self.seq_num         = 0
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              # ── Use pmt.intern() directly, NOT self.pmt_intern() ──
              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")   # ← pmt.intern not self.pmt_intern
              )

              for tag in tags:
                  offset  = tag.offset

                  # Measure actual packet samples between tags
                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      #print(f"[User {self.user_id}] "
                      #      f"Measured packet_samples = {measured}")
                  self.last_tag_offset = offset

                  self.seq_num += 1

                  # Add user_id tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("user_id"),         # ← pmt.intern
                      pmt.from_long(self.user_id)    # ← pmt.from_long
                  )

                  # Add sequence number tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("seq_num"),
                      pmt.from_long(self.seq_num)
                  )

                  # Add timestamp tag
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("tx_time"),
                      pmt.from_double(time.time())   # ← pmt.from_double
                  )

                  print(f"[User {self.user_id}] Tagged PKT "
                        f"seq={self.seq_num} offset={offset}")

              return len(inp)
    packet_samples: '34079'
    samp_rate: samp_rate
    user_id: user_id
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX1.dat
  states: {}
- name: iq1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samples1.dat
  states: {}
- name: iq2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX2.dat
  states: {}
- name: iq2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samples2.dat
  states: {}
- name: iq_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_add.dat
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 2,0,1,3
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: timestamp1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps1_1.txt
  states: {}
- name: timestamp1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx1_2.txt
  states: {}
- name: timestamp2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps2_1.txt
  states: {}
- name: timestamp2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx2_2.txt
  states: {}
- name: timestamp_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamp_add.txt
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: f_samp2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: f_samp2
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    bind: 'False'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:49203
    bind: 'False'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', epy_block_1_0_0_1, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0_0, '0', epy_block_1_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_file_meta_sink_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_file_meta_sink_0_0, '0']
- [digital_constellation_modulator_0_0, '0', epy_block_1_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_crc32_bb_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_0_0, '0', digital_crc32_bb_0_0, '0']
- [epy_block_1, '0', fft_filter_xxx_0_0_0, '0']
- [epy_block_1_0, '0', zeromq_push_sink_0, '0']
- [epy_block_1_0_0, '0', blocks_add_xx_0, '0']
- [epy_block_1_0_0_0, '0', blocks_add_xx_0, '1']
- [epy_block_1_0_0_1, '0', zeromq_pub_sink_0, '0']
- [epy_block_1_1, '0', fft_filter_xxx_0_0_0_0, '0']
- [epy_block_2, pdu_out, blocks_message_debug_0, print]
- [epy_block_2, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_2_0, pdu_out, blocks_message_debug_0_0, print]
- [epy_block_2_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_3_0, '0', virtual_sink_0, '0']
- [epy_block_3_0_0, '0', virtual_sink_0_1, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [fft_filter_xxx_0_0_0_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0, '0', epy_block_3_0, '0']
- [mmse_resampler_xx_0_0, '0', epy_block_3_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', blocks_throttle2_0_0, '0']
- [virtual_source_1_1, '0', epy_block_1_0_0, '0']
- [virtual_source_1_1_0, '0', epy_block_1_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
