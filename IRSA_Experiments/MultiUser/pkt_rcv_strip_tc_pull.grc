options:
  parameters:
    author: Barry Duggan
    description: packet receive
    generate_options: qt_gui
    id: pkt_rcv_strip
    output_language: python
    title: pkt_rcv_strip
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: Infile
  id: parameter
  parameters:
    label: filename
    type: str
    value: log.txt
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time   # ← ADD THIS
      import csv    # ← Move this here too (avoid re-importing inside the loop)

      class blk(gr.basic_block):
          def __init__(self, output_file="output.bin", log_file="rx_log.csv"):
              gr.basic_block.__init__(self, name="EPB: Decode Packet",
                  in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.log_file = log_file
              self.rx_count = 0
              with open(self.log_file, 'w', newline='') as f:
                  csv.writer(f).writerow([
                      'rx_count', 'timestamp', 'user_id',
                      'seq_num', 'crc_ok', 'data_hex'
                  ])

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)

              # ── Extract user_id and seq_num from metadata ──────────────
              user_id = -1
              seq_num = -1
              if pmt.is_dict(meta):
                  if pmt.dict_has_key(meta, pmt.intern("user_id")):
                      user_id = pmt.to_long(
                          pmt.dict_ref(meta, pmt.intern("user_id"), pmt.PMT_NIL))
                  if pmt.dict_has_key(meta, pmt.intern("seq_num")):
                      seq_num = pmt.to_long(
                          pmt.dict_ref(meta, pmt.intern("seq_num"), pmt.PMT_NIL))

              # ── Decode payload ──────────────────────────────────────────
              bytes_out = bytes(pmt.u8vector_elements(data))
              data_hex  = ' '.join(f'{b:02X}' for b in bytes_out)

              self.rx_count += 1
              timestamp = time.strftime('%H:%M:%S')

              print(f"[RX {self.rx_count:03d}] User={user_id} "
                    f"Seq={seq_num} | {data_hex[:20]}...")

              # ── Log ────────────────────────────────────────────────────
              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      self.rx_count, timestamp, user_id,
                      seq_num, True, data_hex
                  ])

              self.message_port_pub(pmt.intern("pdu_out"), pdu)

      '''
      How to Measure ALOHA Performance from the Logs

      Once both TX logs and this RX log are running, you can directly compute:

      Packet Delivery Ratio = RX packets decoded / TX packets sent per user

      Collision rate = slots where both users tagged same offset /
                       total slots

      Throughput = successfully decoded packets / total slots
      '''


      class blk(gr.basic_block):
          def __init__(self, output_file="output.bin", log_file="rx_log.csv"):
              gr.basic_block.__init__(self, name="EPB: Decode Packet",
                  in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.log_file = log_file
              self.rx_count = 0

              # Initialize log
              with open(self.log_file, 'w', newline='') as f:
                  import csv
                  csv.writer(f).writerow([
                      'rx_count', 'timestamp', 'user_id', 
                      'seq_num', 'crc_ok', 'data_hex'
                  ])

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)

              # ── Extract user_id and seq_num from metadata ──────────────
              user_id = -1
              seq_num = -1
              if pmt.is_dict(meta):
                  if pmt.dict_has_key(meta, pmt.intern("user_id")):
                      user_id = pmt.to_long(
                          pmt.dict_ref(meta, pmt.intern("user_id"), pmt.PMT_NIL))
                  if pmt.dict_has_key(meta, pmt.intern("seq_num")):
                      seq_num = pmt.to_long(
                          pmt.dict_ref(meta, pmt.intern("seq_num"), pmt.PMT_NIL))

              # ── Decode payload ──────────────────────────────────────────
              bytes_out = bytes(pmt.u8vector_elements(data))
              data_hex  = ' '.join(f'{b:02X}' for b in bytes_out)

              self.rx_count += 1
              timestamp = time.strftime('%H:%M:%S')

              print(f"[RX {self.rx_count:03d}] User={user_id} "
                    f"Seq={seq_num} | {data_hex[:20]}...")

              # ── Log ────────────────────────────────────────────────────
              with open(self.log_file, 'a', newline='') as f:
                  import csv
                  csv.writer(f).writerow([
                      self.rx_count, timestamp, user_id,
                      seq_num, True, data_hex
                  ])

              self.message_port_pub(pmt.intern("pdu_out"), pdu)

      '''
      How to Measure ALOHA Performance from the Logs

      Once both TX logs and this RX log are running, you can directly compute:

      Packet Delivery Ratio = RX packets decoded / TX packets sent per user

      Collision rate = slots where both users tagged same offset /
                       total slots

      Throughput = successfully decoded packets / total slots
      '''
    comment: |-
      Strip preamble and postamble
      Convert Base64 to original file content
    log_file: rx_log
    output_file: output_filename
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, filename="pdu_log.txt"):
              gr.sync_block.__init__(
                  self,
                  name="pdu_logger",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)
              
              self.log_file = open(filename, 'w')
              self.packet_count = 0
              
          def handle_pdu(self, pdu):
              # Log PDU metadata
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)
              
              timestamp = time.time()
              self.packet_count += 1
              
              # Write to log file
              log_entry = f"Packet {self.packet_count} | Time: {timestamp} | "
              log_entry += f"Length: {pmt.length(data)} bytes\n"
              
              if pmt.is_dict(meta):
                  log_entry += f"Metadata: {pmt.to_python(meta)}\n"
              
              self.log_file.write(log_entry)
              self.log_file.flush()
              
              # Pass PDU through
              self.message_port_pub(pmt.intern('pdu_out'), pdu)
          
          def __del__(self):
              self.log_file.close()
    filename: Infile
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq
    timestamp_filename: timestamp
  states: {}
- name: iq
  id: parameter
  parameters:
    label: filename
    type: str
    value: iq_samplesRx.dat
  states: {}
- name: output_filename
  id: parameter
  parameters:
    label: file
    type: str
    value: output.bin
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(usrp_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: rx_log
  id: parameter
  parameters:
    label: file
    type: str
    value: rx_log.csv
  states: {}
- name: timestamp
  id: parameter
  parameters:
    label: filename
    type: str
    value: timestampsRx.txt
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: stream_tagged
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: stream_tagged
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    bind: 'True'
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1, pdu_out, epy_block_0, pdu_in]
- [epy_block_2, '0', digital_constellation_decoder_cb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', blocks_message_debug_0, print]
- [virtual_source_1, '0', epy_block_1, pdu_in]
- [virtual_source_2, '0', digital_map_bb_0, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
