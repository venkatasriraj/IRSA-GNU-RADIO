options:
  parameters:
    author: Barry Duggan
    description: Multi-user ALOHA TX/RX loopback channel with slot-aware collision detection
    generate_options: qt_gui
    id: chan_loopback_multiuser
    output_language: python
    title: chan_loopback_multiuser
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    mutable: 'True'
    num_opts: '2'
    option_attributes: {}
    option0: '768000'
    option1: '576000'
    options: '[768000, 576000]'
    type: int
    value: '768000'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    stop: '1'
    step: 10m
    value: '0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-100m'
    stop: 100m
    step: 1m
    value: '0'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: 999m
    stop: '1.001'
    step: 100u
    value: '1'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: epy_slot_combiner
  id: epy_block
  parameters:
    _source_code: |
      """
      epy_slot_combiner.py — paste full content of epy_slot_combiner.py here
      """
      # See epy_slot_combiner.py for the full implementation.
      # In GRC, open this block, click '...' next to source code,
      # and paste the entire content of epy_slot_combiner.py
    addr1: tcp://127.0.0.1:49212
    addr2: tcp://127.0.0.1:49213
    packet_samples: '34079'
    slot_timeout_ms: '50'
    comment: |-
      ALOHA Slot Combiner
      Binds to :49212 (User1) and :49213 (User2)
      TX flowgraphs must PUSH+connect to these ports
      No stream inputs — source block
  states: {}
- name: channels_channel_model
  id: channels_channel_model
  parameters:
    K: '4.0'
    N: '8'
    bandwidth: '0'
    epsilon: time_offset
    fc: '0.0'
    fv: freq_offset
    ift_len: '512'
    noise_volt: noise_volt
    seed: '0'
    taps: '[taps]'
  states: {}
- name: blocks_throttle
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_sink
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    comment: Broadcasts combined channel output to all receivers
    timeout: '100'
    type: complex
  states: {}

connections:
- [epy_slot_combiner, '0', channels_channel_model, '0']
- [channels_channel_model, '0', blocks_throttle, '0']
- [blocks_throttle, '0', zeromq_pub_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
