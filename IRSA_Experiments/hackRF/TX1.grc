options:
  parameters:
    author: sriraj
    description: packet transmit
    generate_options: qt_gui
    id: hackRF
    output_language: python
    title: TX1_hackRF
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''10101010101010101010101011100001010110101110100010010011'''
  states: {}
- name: amp_norm
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (samp_rate//sps)*(1+excess_bw)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: int(bw//2)
    gain: '1.0'
    samp_rate: samp_rate
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: samp_rate/usrp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 2*(10**6)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_norm
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: tx1
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_1
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv",total_packets = 5):

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              """
              Assemble the byte payload:
                  [seq_hi, seq_lo, uid_hi, uid_lo, *random_bytes]
              """
              header = [
                  (seq          >> 8) & 0xFF,   # seq high byte
                   seq                & 0xFF,   # seq low byte
                  (self.user_id >> 8) & 0xFF,   # user_id high byte
                   self.user_id       & 0xFF,   # user_id low byte
              ]
              random_bytes = [random.randint(0, 255)
                              for _ in range(self.packet_size - len(header))]
              return header + random_bytes

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              time.sleep(random.uniform(0, self.mean_interval))
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    log_file: log_file1
    mean_interval: '10'
    packet_size: '20'
    total_packets: '20'
    user_id: '1'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, user_id=0, samp_rate=768000, packet_samples=100000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.samp_rate       = samp_rate
              self.packet_samples  = packet_samples
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")
              )

              for tag in tags:
                  offset = tag.offset

                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      # print(f"Measured packet_samples = {measured}")

                  self.last_tag_offset = offset

                  now = time.time()
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("rx_time"),
                      pmt.from_double(now)
                  )
                  print(f"[seq_tagger] PKT offset={offset} rx_time={now:.6f}")

              return len(inp)
    packet_samples: '85333'
    samp_rate: usrp_rate
    user_id: user_id1
  states: {state: disabled}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX1.csv
  states: {}
- name: iq1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd1.csv
  states: {}
- name: iq2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX2.csv
  states: {}
- name: iq2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd2.csv
  states: {}
- name: iq_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_Aadd.csv
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0  / ( ( usrp_rate / samp_rate )  )
    type: complex
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: BEFORE RF CHAIN
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: FFT O/P
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data 1
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: usrp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: 24m
    size: '1024'
    srate: usrp_rate
    type: complex
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    center_freq: fc
    dev_args: driver=hackrf
    samp_rate: usrp_rate
    type: fc32
    vga: '47'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_tag_debug_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_1, '0', fft_filter_xxx_0_0_0, '0']
- [epy_block_2, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_3_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_3_0, '0', qtgui_time_sink_x_1, '0']
- [fft_filter_xxx_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0_0_0, '0']
- [fft_filter_xxx_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [fft_filter_xxx_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [mmse_resampler_xx_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [mmse_resampler_xx_0_0_0, '0', epy_block_3_0, '0']
- [mmse_resampler_xx_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
