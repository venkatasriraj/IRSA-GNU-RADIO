options:
  parameters:
    author: Barry Duggan, updated by Gary Schafer
    category: Custom
    description: Using Diff Enc / Replaced Polyphase Clock Sync with Symbol Sync
    generate_options: qt_gui
    id: bpsk_stage6_ver2
    output_language: python
    title: bpsk_stage6_ver2
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: cmaEqualizer
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: loop_order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    start: '50e-3'
    step: '0.1e-3'
    stop: '100e-3'
    value: '62.8e-3'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: 'Value: firdes.root_raised_cosine(1, samp_rate, samp_rate/float(sps), excess_bw, 11*nfilts)'
    value: firdes.root_raised_cosine(1, samp_rate, samp_rate/float(sps), excess_bw, 11*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    start: '40e-3'
    step: '0.1e-3'
    stop: '100e-3'
    value: '45e-3'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    start: 99e6
    step: 1e3
    stop: 105e6
    value: 100e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (10, -10)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (10j, -10j)
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: loop_order
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cmaEqualizer
    num_taps: '7'
    sps: '1'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Filter the signal with
      a matched filter.
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tuning - center_freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 0.5e6, 200e3)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.3'
    alpha3: '0.3'
    color3: '"red"'
    comment: 2,0,10,10
    grid: 'True'
    gui_hint: 2,0,10,10
    legend: 'False'
    marker2: '-1'
    marker3: '-1'
    name: Recovered Constellation
    nconnections: '3'
    size: '1024'
    style2: '1'
    style3: '1'
    type: complex
    width2: '2'
    width3: '2'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 12,0,10,20
    fc: '0'
    fftsize: '4096'
    gui_hint: 12,0,10,20
    label1: Received Spectrum
    label2: Filtered Spectrum
    nconnections: '3'
    type: complex
    ymax: '0'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: center_freq
    dev_args: driver=hackrf
    gain: '40'
    samp_rate: samp_rate
    type: fc32
    vga: '50'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '"symbol_sync"'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: costasLoop
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '"symbol_sync"'
  states: {}

connections:
- [blocks_vector_source_x_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_vector_source_x_0_0, '0', qtgui_const_sink_x_0, '2']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [fft_filter_xxx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fft_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
