options:
  parameters:
    author: Barry Duggan
    description: packet receive
    generate_options: qt_gui
    id: pkt_rcv_strip
    output_language: python
    title: pkt_rcv_strip
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: Infile
  id: parameter
  parameters:
    label: filename
    type: str
    value: log.txt
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '''11100001010110101110100010010011'''
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import csv


      class blk(gr.basic_block):
          """
          EPB: Decode Packet

          Extracts seq_num and user_id from the fixed 4-byte payload header
          that was embedded by random_packet_generator at TX:

              byte 0-1 : seq_num  (big-endian uint16)
              byte 2-3 : user_id  (big-endian uint16)
              byte 4+  : random payload

          Logs every received packet to CSV and forwards the full PDU
          downstream (to PDU to Tagged Stream → File Sink).
          """

          def __init__(self, output_file="output.bin", log_file="rx_log.csv"):
              gr.basic_block.__init__(self,
                  name="EPB: Decode Packet",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)

              self.log_file  = log_file
              self.rx_count  = 0

              # Initialise log file with header
              with open(self.log_file, 'w', newline='') as f:
                  csv.writer(f).writerow([
                      'rx_count', 'timestamp',
                      'user_id', 'seq_num',
                      'payload_len', 'data_hex'
                  ])

          # ------------------------------------------------------------------
          def handle_pdu(self, pdu):
              # PDU = (meta, data)  — data is the full byte vector from CRC32
              data_bytes = bytes(pmt.u8vector_elements(pmt.cdr(pdu)))

              # ── Validate minimum length ────────────────────────────────
              if len(data_bytes) < 4:
                  print(f"[RX] WARNING: packet too short ({len(data_bytes)} bytes), skipping")
                  return

              # ── Extract header fields from payload bytes ───────────────
              #    DO NOT read from PMT metadata — it is gone after demod
              seq_num = (data_bytes[0] << 8) | data_bytes[1]   # bytes 0-1
              user_id = (data_bytes[2] << 8) | data_bytes[3]   # bytes 2-3
              payload = data_bytes[4:]                          # bytes 4+

              # ── Logging ────────────────────────────────────────────────
              self.rx_count += 1
              timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                           f".{int((time.time() % 1) * 1000):03d}")
              data_hex  = ' '.join(f'{b:02X}' for b in data_bytes)

              print(f"[RX {self.rx_count:03d}] user_id={user_id} "
                    f"seq={seq_num:#06x} "
                    f"payload_len={len(payload)} "
                    f"| first 4B: {data_hex.split()[:4]}")

              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      self.rx_count,
                      timestamp,
                      user_id,
                      seq_num,
                      len(payload),
                      data_hex
                  ])

              # ── Forward full PDU downstream ────────────────────────────
              # Stream CRC32 (Check mode) already discarded bad packets,
              # so every packet reaching here is CRC-valid.
              self.message_port_pub(pmt.intern("pdu_out"), pdu)
    comment: |-
      Strip preamble and postamble
      Convert Base64 to original file content
    log_file: rx_log
    output_file: output_filename
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import pmt
      import time
      import csv


      class blk(gr.basic_block):   # ← MUST be basic_block, not sync_block
          """
          PDU Logger

          Logs every PDU that passes through to a text log and a CSV.
          Also extracts seq_num and user_id from the fixed 4-byte payload
          header so you can check whether packets are arriving at all,
          even if EPB Decode Packet is not printing anything.

          Payload header (set by random_packet_generator):
              bytes 0-1 : seq_num  (big-endian uint16)
              bytes 2-3 : user_id  (big-endian uint16)
              bytes 4+  : random payload
          """

          def __init__(self, filename="log.txt"):
              gr.basic_block.__init__(       # ← basic_block init
                  self,
                  name="pdu_logger",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)

              self.packet_count   = 0
              self.bad_crc_count  = 0   # incremented if crc_fail tag seen
              self.filename       = filename

              # ── Text log ──────────────────────────────────────────────
              self.log_file = open(filename, 'w')
              self.log_file.write("=== PDU Logger started ===\n")
              self.log_file.flush()

              # ── CSV log (same folder, .csv extension) ─────────────────
              csv_name = filename.replace('.txt', '_pdu.csv') \
                         if filename.endswith('.txt') else filename + '.csv'
              self._csv_fh = open(csv_name, 'w', newline='')
              self._csv    = csv.writer(self._csv_fh)
              self._csv.writerow([
                  'pkt_num', 'timestamp',
                  'user_id', 'seq_num',
                  'pkt_len_bytes', 'crc_ok',
                  'first_8_bytes_hex'
              ])
              self._csv_fh.flush()

          # ------------------------------------------------------------------
          def handle_pdu(self, pdu):
              meta       = pmt.car(pdu)
              data_vec   = pmt.cdr(pdu)
              data_bytes = bytes(pmt.u8vector_elements(data_vec))
              pkt_len    = len(data_bytes)

              self.packet_count += 1
              timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                           f".{int((time.time() % 1)*1000):03d}")

              # ── Extract seq_num / user_id from payload bytes ──────────
              #    (PMT metadata keys are gone after demodulation)
              seq_num = user_id = -1
              if pkt_len >= 4:
                  seq_num = (data_bytes[0] << 8) | data_bytes[1]
                  user_id = (data_bytes[2] << 8) | data_bytes[3]

              # ── Check if CRC-fail tag is present in metadata ──────────
              crc_ok = True
              if pmt.is_dict(meta):
                  if pmt.dict_has_key(meta, pmt.intern('crc_fail')):
                      crc_ok = False
                      self.bad_crc_count += 1

              first8 = ' '.join(f'{b:02X}' for b in data_bytes[:8])

              # ── Text log ──────────────────────────────────────────────
              line = (f"[PKT {self.packet_count:04d}] {timestamp} "
                      f"user_id={user_id} seq={seq_num:#06x} "
                      f"len={pkt_len} crc={'OK' if crc_ok else 'FAIL'} "
                      f"| {first8}\n")
              self.log_file.write(line)
              self.log_file.flush()

              # ── CSV log ───────────────────────────────────────────────
              self._csv.writerow([
                  self.packet_count, timestamp,
                  user_id, seq_num,
                  pkt_len, crc_ok,
                  first8
              ])
              self._csv_fh.flush()

              # ── Console (visible in GRC terminal) ────────────────────
              print(f"[PDU_LOG {self.packet_count:04d}] "
                    f"user={user_id} seq={seq_num} "
                    f"len={pkt_len} crc={'OK' if crc_ok else 'FAIL'}")

              # ── Pass PDU through unchanged ────────────────────────────
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

          # ------------------------------------------------------------------
          def __del__(self):
              try:
                  summary = (f"\n=== Session ended | "
                             f"Total: {self.packet_count} | "
                             f"CRC fail: {self.bad_crc_count} ===\n")
                  self.log_file.write(summary)
                  self.log_file.close()
                  self._csv_fh.close()
              except Exception:
                  pass
    filename: Infile
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq
  states: {}
- name: iq
  id: parameter
  parameters:
    label: filename
    type: str
    value: iqRx.csv
  states: {}
- name: output_filename
  id: parameter
  parameters:
    label: file
    type: str
    value: output.bin
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(usrp_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: rx_log
  id: parameter
  parameters:
    label: file
    type: str
    value: rx_log.csv
  states: {}
- name: timestamp
  id: parameter
  parameters:
    label: filename
    type: str
    value: timestampsRx.txt
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: stream_tagged
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: stream_tagged
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    bind: 'True'
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1, pdu_out, epy_block_0, pdu_in]
- [epy_block_2, '0', digital_constellation_decoder_cb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', blocks_message_debug_0, print]
- [virtual_source_1, '0', epy_block_0, pdu_in]
- [virtual_source_1, '0', epy_block_1, pdu_in]
- [virtual_source_2, '0', digital_map_bb_0, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
