options:
  parameters:
    author: venka
    generate_options: qt_gui
    id: accessCode
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''1010101010101010101010101010101011100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (1+excess_bw)*(samp_rate//sps)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (bw//2)+5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '52'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '28'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: user_id3
  id: variable
  parameters:
    value: '3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: Infile
  id: parameter
  parameters:
    label: filename
    type: str
    value: log.txt
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_repeat_0_0_1
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq
  states: {}
- name: epy_block_2_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              # 1. Define a fixed Access Code (Example: 0xAC or 10101100)
              # Use a longer, unique pattern for better correlation (e.g., 32 bits)
              #access_code = [0x1A, 0xCF, 0xFC, 0x1A] 
              # access_code = [0xAA, 0xAA, 0xAA, 0xAA, 0xE1, 0x5A, 0xE8, 0x93]
              access_code = [0xE1, 0x5A, 0xE8, 0x93]

              filler = [0xE1, 0x5A, 0xE8, 0xAA]  # 4B filler pattern to make the preamble more distinct

              # 2. Existing Header [seq_hi, seq_lo, uid_hi, uid_lo]
              header = [
                  (seq >> 8) & 0xFF,
                  seq & 0xFF,
                  (self.user_id >> 8) & 0xFF,
                  self.user_id & 0xFF,
              ]
              
              # 3. Random Data
              payload_len = self.packet_size - len(access_code) - len(header)
              random_bytes = [random.randint(0, 255) for _ in range(payload_len)]
              
              # Total Packet: [Preamble] + [Header] + [Payload] + [Filler]
              # Note: CRC will be added by the Async CRC32 block after this
              return access_code + header + random_bytes + filler

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '0'
    log_file: log_file2
    mean_interval: '0.5'
    packet_size: packet_size
    total_packets: '20'
    user_id: user_id2
  states: {}
- name: epy_block_2_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              # 1. Define a fixed Access Code (Example: 0xAC or 10101100)
              # Use a longer, unique pattern for better correlation (e.g., 32 bits)
              #access_code = [0x1A, 0xCF, 0xFC, 0x1A] 
              # access_code = [0xAA, 0xAA, 0xAA, 0xAA, 0xE1, 0x5A, 0xE8, 0x93]
              access_code = [0xE1, 0x5A, 0xE8, 0x93]

              filler = [0xE1, 0x5A, 0xE8, 0xAA]  # 4B filler pattern to make the preamble more distinct

              # 2. Existing Header [seq_hi, seq_lo, uid_hi, uid_lo]
              header = [
                  (seq >> 8) & 0xFF,
                  seq & 0xFF,
                  (self.user_id >> 8) & 0xFF,
                  self.user_id & 0xFF,
              ]
              
              # 3. Random Data
              payload_len = self.packet_size - len(access_code) - len(header)
              random_bytes = [random.randint(0, 255) for _ in range(payload_len)]
              
              # Total Packet: [Preamble] + [Header] + [Payload] + [Filler]
              # Note: CRC will be added by the Async CRC32 block after this
              return access_code + header + random_bytes + filler

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '0'
    log_file: log_file1
    mean_interval: '1'
    packet_size: packet_size
    total_packets: '20'
    user_id: user_id1
  states: {}
- name: epy_block_2_1_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              # 1. Define a fixed Access Code (Example: 0xAC or 10101100)
              # Use a longer, unique pattern for better correlation (e.g., 32 bits)
              #access_code = [0x1A, 0xCF, 0xFC, 0x1A] 
              # access_code = [0xAA, 0xAA, 0xAA, 0xAA, 0xE1, 0x5A, 0xE8, 0x93]
              access_code = [0xE1, 0x5A, 0xE8, 0x93]

              filler = [0xE1, 0x5A, 0xE8, 0xAA]  # 4B filler pattern to make the preamble more distinct

              # 2. Existing Header [seq_hi, seq_lo, uid_hi, uid_lo]
              header = [
                  (seq >> 8) & 0xFF,
                  seq & 0xFF,
                  (self.user_id >> 8) & 0xFF,
                  self.user_id & 0xFF,
              ]
              
              # 3. Random Data
              payload_len = self.packet_size - len(access_code) - len(header)
              random_bytes = [random.randint(0, 255) for _ in range(payload_len)]
              
              # Total Packet: [Preamble] + [Header] + [Payload] + [Filler]
              # Note: CRC will be added by the Async CRC32 block after this
              return access_code + header + random_bytes + filler

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '0'
    log_file: log_file3
    mean_interval: '0.09'
    packet_size: packet_size
    total_packets: '20'
    user_id: user_id3
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import csv
      import time

      class access_code_correlator(gr.sync_block):
          """
          Bitwise sliding-window access code correlator (no CRC).

          Input  : stream of unpacked bits (uint8, values 0 or 1)
                   — straight from Differential Decoder output.
          Output : same bit stream, passed through unchanged.
          Message: 'pdu_out' — fires a PDU for every detected packet.

          Packet wire format (no CRC block in TX chain):
              [access_code : 4 B]   <- correlated against, then consumed
              [seq_num     : 2 B big-endian uint16]
              [user_id     : 2 B big-endian uint16]
              [random data : (packet_size - 8) B]

          Parameters
          ----------
          packet_size : int
              Total bytes produced by Random_Packet_Generator (default 100).
          threshold : int
              Minimum bit matches out of 32 to accept access code (default 28).
          log_file : str
              Path for the CSV log of decoded packets.
          """

          ACCESS_CODE_BYTES = [0xE1, 0x5A, 0xE8, 0x93]   # must match TX

          def __init__(self,
                       packet_size=100,
                       threshold=28,
                       log_file="rx_decoded_packets.csv"):

              gr.sync_block.__init__(self,
                  name="access_code_correlator",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])          # passthrough

              self.message_port_register_out(pmt.intern('pdu_out'))

              self.packet_size = int(packet_size)
              self.threshold   = int(threshold)
              self.log_file    = log_file

              # Access code as bit array, MSB first per byte
              self.ac_bits = np.array(
                  [int(b) for byte in self.ACCESS_CODE_BYTES
                           for b in format(byte, '08b')],
                  dtype=np.uint8
              )
              self.ac_len = len(self.ac_bits)   # 32

              # After consuming the 4-byte AC, collect the rest of the packet:
              # seq(2) + uid(2) + random(packet_size - 8) = packet_size - 4 bytes
              self.post_ac_bits = (packet_size - 4) * 8

              # Internal state
              self._buf          = np.empty(0, dtype=np.uint8)
              self._state        = 'SEARCH'
              self._collect_bits = []
              self._pkt_count    = 0

              # CSV init
              with open(self.log_file, 'w', newline='') as f:
                  csv.writer(f).writerow([
                      'pkt_index', 'rx_time', 'user_id', 'seq_num',
                      'payload_hex', 'payload_len_bytes'
                  ])

          # -- Helpers -------------------------------------------------------

          @staticmethod
          def _bits_to_bytes(bits):
              """Pack flat bit list/array (MSB first) into list of ints."""
              result = []
              for i in range(len(bits) // 8):
                  byte = 0
                  for b in bits[i*8 : i*8+8]:
                      byte = (byte << 1) | int(b)
                  result.append(byte)
              return result

          # -- Packet processing ---------------------------------------------

          def _process_packet(self, collect_bits):
              raw_bytes = self._bits_to_bytes(collect_bits)

              # Need at least seq(2) + uid(2) = 4 bytes
              if len(raw_bytes) < 4:
                  print(f"[AC_CORR] WARNING: packet too short ({len(raw_bytes)} B), discarding")
                  return

              seq_num = (raw_bytes[0] << 8) | raw_bytes[1]
              user_id = (raw_bytes[2] << 8) | raw_bytes[3]
              payload = raw_bytes[4:]

              self._pkt_count += 1

              print(
                  f"[AC_CORR PKT {self._pkt_count:04d}] "
                  f"user_id={user_id}  "
                  f"seq_num={seq_num} ({seq_num:#06x})  "
                  f"payload={len(payload)} B"
              )

              now     = time.time()
              rx_time = time.strftime('%Y-%m-%d %H:%M:%S', time.localtime(now)) \
                        + f".{int((now % 1) * 1000):03d}"
              pay_hex = ' '.join(f'{b:02X}' for b in payload)

              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      self._pkt_count, rx_time, user_id, seq_num,
                      pay_hex, len(payload)
                  ])

              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('user_id'), pmt.from_long(user_id))
              meta = pmt.dict_add(meta, pmt.intern('seq_num'),  pmt.from_long(seq_num))
              pdu  = pmt.cons(meta, pmt.init_u8vector(len(raw_bytes), raw_bytes))
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

          # -- GNU Radio work() ----------------------------------------------

          def work(self, input_items, output_items):
              in0  = input_items[0]
              out0 = output_items[0]
              out0[:] = in0                    # passthrough

              self._buf = np.concatenate([self._buf, in0])

              while True:

                  if self._state == 'SEARCH':
                      if len(self._buf) < self.ac_len:
                          break

                      # Vectorised correlation - entire buffer in one numpy call
                      n_windows = len(self._buf) - self.ac_len + 1
                      strides   = (self._buf.strides[0], self._buf.strides[0])
                      windows   = np.lib.stride_tricks.as_strided(
                                      self._buf,
                                      shape=(n_windows, self.ac_len),
                                      strides=strides)
                      corrs = np.sum(windows == self.ac_bits, axis=1)
                      hits  = np.where(corrs >= self.threshold)[0]

                      if len(hits) == 0:
                          self._buf = self._buf[-(self.ac_len - 1):]
                          break

                      idx = int(hits[0])
                      print(f"[AC_CORR] Access code @ buf[{idx}] corr={int(corrs[idx])}/32")
                      self._buf          = self._buf[idx + self.ac_len:]
                      self._state        = 'COLLECT'
                      self._collect_bits = []

                  elif self._state == 'COLLECT':
                      still_need = self.post_ac_bits - len(self._collect_bits)

                      if len(self._buf) >= still_need:
                          self._collect_bits.extend(self._buf[:still_need].tolist())
                          self._buf = self._buf[still_need:]
                          self._process_packet(self._collect_bits)
                          self._state = 'SEARCH'
                          # loop - another packet may follow immediately
                      else:
                          self._collect_bits.extend(self._buf.tolist())
                          self._buf = np.empty(0, dtype=np.uint8)
                          break

              return len(in0)
    log_file: rx_log
    packet_size: packet_size
    threshold: thresh
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq
  id: parameter
  parameters:
    label: filename
    type: str
    value: iqRx.csv
  states: {}
- name: iq1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX1.csv
  states: {}
- name: iq1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd1.csv
  states: {}
- name: iq2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX2.csv
  states: {}
- name: iq2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd2.csv
  states: {}
- name: iq_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_Aadd.csv
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: log_file3
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx3.csv
  states: {}
- name: output_filename
  id: parameter
  parameters:
    label: file
    type: str
    value: output.bin
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    name: RX_Cos
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: RX_Sym
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 1,0,1,2
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '2048'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: rx_log
  id: parameter
  parameters:
    label: file
    type: str
    value: rx_log.csv
  states: {}
- name: timestamp
  id: parameter
  parameters:
    label: filename
    type: str
    value: timestampsRx.txt
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: ch_out
  states: {}
- name: virtual_sink_0_1_0_1
  id: virtual_sink
  parameters:
    stream_id: sig2
  states: {}
- name: virtual_sink_0_1_0_1_0
  id: virtual_sink
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_sink_0_1_0_1_1
  id: virtual_sink
  parameters:
    stream_id: sig3
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: sig2
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: sig3
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: ch_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_const_source_x_0_0_1, '0', blocks_float_to_complex_0_0_1, '1']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_float_to_complex_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_float_to_complex_0_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [blocks_multiply_xx_0_0, '0', fft_filter_xxx_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', fft_filter_xxx_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', fft_filter_xxx_0_0_0_0_1, '0']
- [blocks_repeat_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_repeat_0_0_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_repeat_0_0_1, '0', blocks_float_to_complex_0_0_1, '0']
- [blocks_throttle2_0_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_1, '0', blocks_repeat_0_0_1, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_repeat_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [digital_constellation_modulator_0_0_0_1, '0', blocks_multiply_xx_0_0_1, '0']
- [digital_costas_loop_cc_0, '0', epy_block_2_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_map_bb_0, '0', virtual_sink_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [epy_block_0_0, '1', blocks_uchar_to_float_0_0, '0']
- [epy_block_0_0_0, '0', digital_constellation_modulator_0_0_0_1, '0']
- [epy_block_0_0_0, '1', blocks_uchar_to_float_0_0_1, '0']
- [epy_block_0_1, '0', digital_constellation_modulator_0_0_0_0, '0']
- [epy_block_0_1, '1', blocks_uchar_to_float_0_1, '0']
- [epy_block_2_0, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_2_1, pdu_out, epy_block_0_0, pdus]
- [epy_block_2_1_0, pdu_out, epy_block_0_1, pdus]
- [epy_block_2_1_1, pdu_out, epy_block_0_0_0, pdus]
- [epy_block_3, '0', blocks_null_sink_0, '0']
- [epy_block_3, pdu_out, blocks_message_debug_0, print]
- [fft_filter_xxx_0_0_0_0, '0', virtual_sink_0_1_0_1, '0']
- [fft_filter_xxx_0_0_0_0_0, '0', virtual_sink_0_1_0_1_0, '0']
- [fft_filter_xxx_0_0_0_0_1, '0', virtual_sink_0_1_0_1_1, '0']
- [virtual_source_1_0, '0', blocks_add_xx_0, '1']
- [virtual_source_1_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_1_0_1, '0', blocks_add_xx_0, '2']
- [virtual_source_1_1, '0', digital_fll_band_edge_cc_0, '0']
- [virtual_source_2, '0', epy_block_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
