options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: file.txt
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: |
      """
      Embedded Python Block: File Source to Tagged Stream
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt
      import os.path
      import sys
      import base64

      """
      State definitions
          0   idle
          1   send preamble
          2   send file data
          3   send file name
          4   send post filler
      """

      class blk(gr.sync_block):
          def __init__(self, FileName='None', Pkt_len=52):
              gr.sync_block.__init__(
                  self,
                  name='EPB: File Source to Tagged Stream',
                  in_sig=None,
                  out_sig=[np.uint8]
              )

              self.FileName = FileName
              self.Pkt_len = Pkt_len
              self.state = 0      # idle state
              self.pre_count = 0
              self.indx = 0
              self._debug = 0     # debug
              self.data = ""
              self.nitems_written = 0

              if os.path.exists(self.FileName):
                  self.f_in = open(self.FileName, 'rb')
                  self._eof = False
                  if self._debug:
                      print("File name:", self.FileName)
                  self.state = 1
              else:
                  print(self.FileName, 'does not exist')
                  self._eof = True
                  self.state = 0

              self.char_list = [
                  37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,
                  85,85,85,93
              ]
              self.c_len = len(self.char_list)

              self.filler = [
                  37,85,85,85,35,69,79,70,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,93
              ]
              self.f_len = len(self.filler)

          def work(self, input_items, output_items):

              if self.state == 0:
                  return 0

              elif self.state == 1:
                  if self._debug:
                      print("state = 1", self.pre_count)

                  key1 = pmt.intern("packet_len")
                  val1 = pmt.from_long(self.c_len)

                  if len(output_items[0]) < self.c_len:
                      return 0

                  self.add_item_tag(
                      0,
                      self.nitems_written,
                      key1,
                      val1
                  )

                  self.indx += self.c_len
                  self.nitems_written += self.c_len

                  i = 0
                  while i < self.c_len:
                      output_items[0][i] = self.char_list[i]
                      i += 1

                  self.pre_count += 1
                  if self.pre_count > 64:
                      self.pre_count = 0
                      self.state = 2

                  return self.c_len

              elif self.state == 2:
                  buff = self.f_in.read(self.Pkt_len)
                  b_len = len(buff)

                  if b_len == 0:
                      print('End of file')
                      self._eof = True
                      self.f_in.close()
                      self.state = 3
                      self.pre_count = 0
                      return 0

                  encoded = base64.b64encode(buff)
                  e_len = len(encoded)

                  if self._debug:
                      print('b64 length =', e_len)

                  key0 = pmt.intern("packet_len")
                  val0 = pmt.from_long(e_len)

                  if len(output_items[0]) < e_len:
                      return 0

                  self.add_item_tag(
                      0,
                      self.nitems_written,
                      key0,
                      val0
                  )

                  self.indx += e_len
                  self.nitems_written += e_len

                  i = 0
                  while i < e_len:
                      output_items[0][i] = encoded[i]
                      i += 1

                  return e_len

              elif self.state == 3:
                  fn_len = len(self.FileName)

                  key1 = pmt.intern("packet_len")
                  val1 = pmt.from_long(fn_len + 8)

                  if len(output_items[0]) < fn_len + 8:
                      return 0

                  self.add_item_tag(
                      0,
                      self.nitems_written,
                      key1,
                      val1
                  )

                  self.indx += fn_len + 8
                  self.nitems_written += fn_len + 8

                  i = 0
                  while i < 8:
                      output_items[0][i] = self.filler[i]
                      i += 1

                  j = 0
                  while i < (fn_len + 8):
                      output_items[0][i] = ord(self.FileName[j])
                      i += 1
                      j += 1

                  self.state = 4
                  return fn_len + 8

              elif self.state == 4:
                  if self._debug:
                      print("state = 4", self.pre_count)

                  key1 = pmt.intern("packet_len")
                  val1 = pmt.from_long(self.f_len)

                  if len(output_items[0]) < self.f_len:
                      return 0

                  self.add_item_tag(
                      0,
                      self.nitems_written,
                      key1,
                      val1
                  )

                  self.indx += self.f_len
                  self.nitems_written += self.f_len

                  i = 0
                  while i < self.f_len:
                      output_items[0][i] = self.filler[i]
                      i += 1

                  self.pre_count += 1
                  if self.pre_count > 16:
                      self.pre_count = 0
                      self.state = 0

                  return self.f_len

              return 0
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq
    timestamp_filename: timestamp
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\nfrom gnuradio import gr\nimport numpy as np\nimport time\nimport struct\n\nclass iq_logger_with_timestamp(gr.sync_block):\n    def __init__(self, iq_filename=\"iq_samples.dat\", \n                 timestamp_filename=\"timestamps.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"iq_logger_with_timestamp\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        \n        self.iq_file = open(iq_filename, 'wb')\n        self.timestamp_file = open(timestamp_filename, 'w')\n        self.sample_count = 0\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        # Get current timestamp\n        timestamp = time.time()\n        \n        # Write I-Q samples to binary file\n        self.iq_file.write(in0.tobytes())\n        \n        # Log timestamp with sample count\n        num_samples = len(in0)\n        log_entry = f\"{timestamp},{self.sample_count},{num_samples}\\n\"\n        self.timestamp_file.write(log_entry)\n        self.timestamp_file.flush()\n        \n        self.sample_count += num_samples\n        \n        # Pass samples through\n        out0[:] = in0\n        \n        return len(out0)\n    \n    def stop(self):\n        self.iq_file.close()\n        self.timestamp_file.close()\n        return True\n\n\n# ```\n\n# Save this as `iq_logger_with_timestamp.py`\n\n# ### In GRC:\n# ```\n# [Modulator] → [Custom IQ Logger] → [USRP Sink]\n\n"
    iq_filename: iq1
    timestamp_filename: timestamp1
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX.dat
  states: {}
- name: iq1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samples1.dat
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: timestamp
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx.txt
  states: {}
- name: timestamp1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps1.txt
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0_0, '0', epy_block_1_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', blocks_file_meta_sink_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_1, '0', fft_filter_xxx_0_0_0, '0']
- [epy_block_1_0, '0', zeromq_pub_sink_0, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
